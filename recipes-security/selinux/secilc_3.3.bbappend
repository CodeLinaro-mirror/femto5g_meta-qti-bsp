SRC_URI:remove = "git://github.com/SELinuxProject/selinux.git;branch=master;protocol=https"
SRC_URI:prepend = " git://git.codelinaro.org/clo/yocto-mirrors/github/selinuxproject/selinux.git;branch=master;protocol=https "
