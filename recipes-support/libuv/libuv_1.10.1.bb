require libuv.inc

SRC_URI = "git://github.com/libuv/libuv.git;branch=v1.x;protocol=https;tag=v${PV}"
SRCREV = "v${PV}"
