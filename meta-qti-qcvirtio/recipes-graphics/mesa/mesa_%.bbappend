FILES:libgbm:append:gvm-gen4-5-virtio = " ${libdir}/gbm/*.so"
RDEPENDS:libgbm:append:gvm-gen4-5-virtio = " libgallium"
