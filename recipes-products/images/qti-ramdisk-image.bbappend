PACKAGE_INSTALL:remove = "ttf-bitstream-vera liberation-fonts cantarell-fonts ttf-dejavu packagegroup-fonts-truetype"

INITRAMFS_MAXSIZE = "196608"
